Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2020-05-21T15:27:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu May 21 15:27:37 2020* Host: NCL-PI17* Database: C:\Users\GroomM\AppData\Local\Temp\{3B1C444A-EE5D-4B9A-9354-3FBCDA10FF54}\ifc* Database version: 5507* Database creation date: Thu May 21 15:27:36 2020* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu May 21 15:27:37 2020* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu May 21 15:27:37 2020* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFlowTerminal: SQUARO INFINITY_1200X900 Quaryl Showertray _UDQ1290SQI2V, NBS_VilleroyAndBoch_ShwrTrys_SQUAROINFINITY_UDQ1290SQI2V:SQUARO INFINITY_1200X900 Quaryl Showertray _UDQ1290SQI2V:308426
In: Level 0
Type - PredefinedType: SHOWER; Classification: Pr_40_20_06_84 (Uniclass2015); Material: NBS_VilleroyAndBoch_SanitaryCeramics_StoneWhite
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VilleroyAndBoch_ShowerTrays_SQUAROINFINITY_1200X900QuarylShowertray_UDQ1290SQI2V; ManufacturerName: Villeroy & Boch; ManufacturerURL: https://pro.villeroy-boch.com/en/gb/home.html; NBSCertification: www.nationalbimlibrary.com/cert/4lgsnz2v; NBSDescription: Shower trays; NBSReference: 45-35-70/336; ProductInformation: https://pro.villeroy-boch.com/en/gb/bw/m/Squaro-Infinity-Shower-tray--UDQ1290SQI2V.html; Revision: n/a; Uniclass2015Title: Shower trays; Uniclass2015Code: Pr_40_20_06_84; Uniclass2015Version: Products v1.17; Version: 1
Type - NBS_Data - IntegralAccessories: n/a; Weight: 29.8 kg
Type - Pset_SanitaryTerminalTypeShower - DrainSize: 90 mm; HasTray: yes; ShowerHeadDescription: n/a; ShowerType: n/a
Type - IFC - IfcExportAs: IfcSanitaryTerminalType; IfcExportType: SHOWER
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_20_06_84:Shower trays; CodePerformance: EN 274; Color: Matt; Constituents: n/a; Description: Showertray; DurationUnit: year; Features: Can be cut to size, anti-slip, quick and easy to clean, long lasting; Finish: n/a; Grade: n/a; Manufacturer: marketing@villeroy-boch.co.uk; Material: Quaryl; ModelNumber: UDQ1290SQI2V; ModelReference: SQUARO INFINITY_1200X900 Quaryl Showertray _UDQ1290SQI2V; Name: ShowerTrays_SQUAROINFINITY_1200X900QuarylShowertray_UDQ1290SQI2V_VilleroyAndBoch; NominalHeight: 40 mm; NominalLength: 1200 mm; NominalWidth: 900 mm; ReplacementCost: n/a; Shape: Rectangular; Size: 40 x 1200 x 900 mm; SustainabilityPerformance: Sustainably manufactured using completely natural materials; WarrantyDurationUnit: year
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
